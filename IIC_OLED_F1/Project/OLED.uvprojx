# Keil uVision project OLED.uvprojx, settings and files
target OLED (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OLED +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_ MD,USE_STDPERIPH_DRIVER
  c include: ..\User\delay;..\User\KEY;..\User\LED;..\User\lnterface;..\User\OLED;..\User\sys;..\User\usart;..\User;..\Libraries\FWlib\inc;..\Libraries\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../User/: main.c stm32f10x_it.c
    ../Libraries/CMSIS/: system_stm32f10x.c
    ../User/delay/: delay.c
    ../User/KEY/: key.c
    ../User/LED/: led.c
    ../User/lnterface/: lnterface.c
    ../User/OLED/: oled.c
    ../User/sys/: sys.c
    ../User/usart/: usart.c
  group CORE
    ../Libraries/CMSIS/: core_cm3.c
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group FWlib
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
